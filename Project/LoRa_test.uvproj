# Keil uVision project LoRa_test.uvproj, settings and files
target LoRa_test (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRa_test +hex
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\list\@L.bin"
  c flags: OneElfS=1
  c define: STM32F10X_MD,  USE_STDPERIPH_DRIVER, USE_SX1276_RADIO, TX_DEVX
  c misc: --c99
  c include: ..\Libraries\CMSIS;..\Libraries\FWLib\inc;..\Source
  asm include: ..\Source;..\Libraries\FWLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group Libaraies
    ../Libraries/FWLib/src/: stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_flash.c misc.c stm32f10x_exti.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_iwdg.c
  group Source
    ../Source/: main.c sx1276.c sx1276-LoRa.c sx1276-Fsk.c sx1276-LoRaMisc.c sx1276-FskMisc.c sx1276-Hal.c spi.c radio.c uart.c adc.c
